# IAR project FetDcdcController.ewp, settings and files
configuration eZ_FET_Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2452 MSP430G2452
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: EZ_FET
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ eZ_FetDcdcController
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2452.xcl
  XLINK.XlinkStackSize: 1
configuration MSP_FET_Debug (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MSP_FET
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ MSP_FetDcdcController
  group (top)
    src/fw/fet/EnergyTrace_TSPA/: VCC_Current.c
